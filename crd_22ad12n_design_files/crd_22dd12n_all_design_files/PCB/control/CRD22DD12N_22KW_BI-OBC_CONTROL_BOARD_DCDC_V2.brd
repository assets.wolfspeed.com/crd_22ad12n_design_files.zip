# Allegro board CRD22DD12N_22KW_BI-OBC_CONTROL_BOARD_DCDC_V2.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DCPWM2A_2L: length 20.6
  TOP w0.152: v1(62.23,35.43) 61.66,34.86 60.64,34.86 60.07,34.29 U58.2
  BOTTOM w0.152: v1(62.23,35.43) 62.23,36.2 65.41,39.37 65.41,47 J3.5
DCPWM2A_2LL: length 30.2
  TOP w0.152: v1(43.69,41.78) 43.31,41.4 43.31,40.26 43.56,40.01 43.56,38.1 43.43,37.98 R421.2 ; v1(60.96,36.83) 60.96,35.84 60.68,35.56 U58.1
  ART03 w0.127: v1(60.96,36.83) 60.12,36.83 57.43,39.52 45.44,39.52 44.42,40.54 44.42,41.05 v1(43.69,41.78)
  BOTTOM w0.152: U28.166 43.22,41.31 v1(43.69,41.78)
DCSHORT: length 38.6
  ART03 w0.127: v1(53.21,36.83) 54.79,36.83 56.51,35.11 57.99,35.11 60.58,32.51 63.63,32.51 69.22,38.1 v1(69.22,38.23)
  BOTTOM w0.152: U28.5 50.91,34.79 51.44,35.31 52.3,35.31 52.65,35.66 52.65,36.27 v1(53.21,36.83) ; v1(69.22,38.23) 69.85,37.59 69.85,33.78 69.98,33.66 73.28,33.66 73.78,33.15 R505.2 C464.1 U61.4
DCVOLT1: length 8.4
  TOP w0.152: v1(92.66,24.03) 92.66,23.62 92.05,23.01 91.72,23.01 R491.2 C455.2
  BOTTOM w0.152: v1(92.66,24.03) 92.3,24.03 R482.1 91.64,24.77 92.49,25.61 93.62,25.61 93.98,25.97 U44.1
IOUT_ADC: length 94
  TOP w0.152: R607.1 58.14,14.76 v1(58.14,10.59)
  ART03 w0.127: J2.14 18.16,48.01 18.16,43.18 14.1,39.12 14.1,16.89 18.41,12.57 22.35,12.57 25.76,9.17 36.6,9.17 38.61,11.18 38.61,11.94 39.22,12.55 52.6,12.55 53.34,11.81 53.34,11.18 54.74,9.78 57.33,9.78 v1(58.14,10.59)
OUTPUT_OC: length 53.7
  TOP w0.152: v1(21.6,46.99) 20.96,46.99 J2.16 14.92,47.32 14.92,41.85 15.88,40.89 D95.3
  ART03 w0.127: v1(52.1,37.88) 42.71,37.88 40.64,39.95 38.53,39.95 37.08,41.4 34.16,41.4 29.21,46.35 22.23,46.35 v1(21.6,46.99)
  BOTTOM w0.152: U28.2 51.02,36.28 51.43,36.7 51.43,37.21 v1(52.1,37.88)
OUTPUT_OC_17227068: length 1.3
  TOP w0.152: R691.2 R689.2
P_ADREF3.2V: length 14.7
  TOP w0.508: C549.2 45.09,14.86 v1(44.71,15.23) ; v1(42.9,15.29) 42.55,14.94 C551.2 ; v1(48.26,20.19) 48.39,20.32 C559.2 C558.2
  BOTTOM w0.254: U28.53 44.22,14.73 v1(44.71,15.23) ; U28.55 43.22,14.98 v1(42.9,15.29) ; v1(48.26,20.19) 48.67,19.79 U28.35 ; U28.37 48.88,18.79 48.59,18.49 47.68,18.49 v1(47.12,19.05)
  vias: v1(50.16,3.81)
P_SCL: length 32.7
  ART03 w0.127: v1(66.67,39.37) 65.79,39.37 64.9,38.48 60.83,38.48 58.38,40.93 48.86,40.93 48.51,41.27 47.24,41.27 v1(46.74,41.78)
  BOTTOM w0.152: v1(46.74,41.78) 47.32,41.2 47.32,39.62 47.22,39.51 U28.174 ; U32.6 65.41,33.78 66.37,34.75 66.37,35.13 R438.1 67.21,35.44 67.44,35.66 67.44,38.61 v1(66.67,39.37)
P_SDA: length 25.4
  ART03 w0.127: v1(46.71,40.64) 47.2,40.16 58.01,40.16 60.33,37.85 61.21,37.85 63.5,35.56 v1(63.5,34.29)
  BOTTOM w0.152: R437.1 64.26,35.44 63.5,34.67 v1(63.5,34.29) 64.14,33.66 U32.5 ; v1(46.71,40.64) U28.173
P_WD_GREEN: length 13.4
  TOP w0.152: D102.2 41.73,43.25 41.02,42.55 v1(40.64,42.55)
  BOTTOM w0.152: v1(40.64,42.55) 40.31,42.87 36.96,42.87 35.96,41.87 33.05,41.87 31.71,40.54 U28.143
P_WD_RED: length 16.9
  TOP w0.152: v1(44.7,42.29) 44.7,42.42 43.87,43.25 D103.2
  BOTTOM w0.152: U28.144 32.22,40.26 33.34,41.38 36.18,41.38 37.25,42.44 39.72,42.44 40.13,42.04 41.55,42.04 42.19,42.67 44.32,42.67 v1(44.7,42.29)
PCS_ADC: length 10.9
  TOP w0.152: R602.2 40.01,7.5 40.64,8.13 v1(40.64,8.89)
  BOTTOM w0.152: C596.1 R606.1 v1(40.64,8.89) 41.02,8.51 41.78,8.51 41.91,8.64 D90.3 41.91,10.09 41.71,10.29 U28.58
PCS_ADC1: length 8.2
  BOTTOM w0.152: U28.59 41.22,11.12 40.77,10.67 39.12,10.67 37.98,9.53 R606.2 36.58,8.89 C597.1
PWM1A: length 43.1
  TOP w0.152: U62.8 65.66,38.1 66.42,38.86 67.06,38.86 67.18,38.99 67.18,40.13 v1(66.67,40.64)
  ART03 w0.152: v1(66.67,40.64) 67.18,41.15 67.18,43.81 62.1,48.9 39.38,48.9 J2.1
PWM1AA: length 27.5
  TOP w0.152: v1(62.87,43.18) 62.23,42.55 62.23,40.26 62.48,40.01 63.75,40.01 64.39,39.37 U62.9 ; R414.2 v1(53.34,34.29)
  BOTTOM w0.152: U28.10 50.95,32.28 51.71,33.05 51.71,33.4 51.94,33.63 52.68,33.63 v1(53.34,34.29) 53.39,34.24 56.51,34.24 57.76,35.49 57.76,39.8 61.14,43.18 v1(62.87,43.18)
PWM1B: length 41.2
  TOP w0.152: v1(66.67,41.91) 66.67,41.71 65.61,40.64 U62.10
  ART03 w0.152: v1(66.67,41.91) 66.67,43.18 61.59,48.26 39.19,48.26 35.86,51.59 34.15,51.59 J2.3
PWM1BB: length 23
  TOP w0.152: R415.2 53.21,33.02 v1(53.09,33.15) ; v1(62.87,41.91) U62.11
  BOTTOM w0.152: U28.12 51.22,31.28 v1(53.09,33.15) 53.9,33.96 56.63,33.96 58.17,35.5 58.17,39.37 60.71,41.91 v1(62.87,41.91)
PWM1C: length 38.8
  TOP w0.152: v1(60.96,44.45) 61.59,44.45 62.1,43.94 63.02,43.94 63.78,43.18 U62.12
  ART03 w0.152: J2.5 31.76,51.44 33.38,51.44 34.11,50.7 34.11,50.09 37.21,46.99 58.42,46.99 v1(60.96,44.45)
PWM1CC: length 29.4
  TOP w0.152: U62.13 v1(62.87,44.45) ; v1(51.94,30.79) 52.25,30.48 R416.2 R610.2
  BOTTOM w0.152: v1(62.87,44.45) 63.5,43.81 63.5,41.66 63.14,41.3 60.83,41.3 58.57,39.04 58.57,35.48 56.77,33.68 54.36,33.68 51.94,31.27 v1(51.94,30.79) U28.13
PWM1D: length 38.8
  TOP w0.152: U62.6 58.8,39.37 56.52,41.66 v1(56.52,41.91)
  ART03 w0.152: v1(56.52,41.91) 54.61,43.81 34.04,43.81 29.02,48.83 29.02,50.99 27.94,52.07 J2.7
PWM1DD: length 22.3
  TOP w0.152: R611.2 R417.2 50.95,30.48 51.84,29.59 v1(51.94,29.59) ; U62.5 v1(60.96,40.64)
  BOTTOM w0.152: v1(60.96,40.64) 58.85,38.53 58.85,35.37 56.88,33.4 54.47,33.4 52.51,31.44 52.51,30.16 v1(51.94,29.59) 51.69,29.59 51,30.28 U28.14
PWM1E: length 41.4
  TOP w0.152: U62.4 v1(57.78,41.91)
  ART03 w0.152: J2.9 26.53,53.85 28.45,53.85 29.02,53.28 29.02,51.75 29.4,51.37 29.4,49.59 34.54,44.45 55.24,44.45 v1(57.78,41.91)
PWM1EE: length 25.7
  TOP w0.152: v1(60.96,39.37) 61.47,39.88 61.47,42.52 60.81,43.18 U62.3
  BOTTOM w0.152: v1(60.96,39.37) 60.58,39.37 59.13,37.92 59.13,35.25 56.98,33.1 54.56,33.1 52.83,31.37 52.83,29.94 52.59,29.69 52.59,27.56 52.21,27.18 51.69,27.18 51.31,26.8 51.31,26.54 51.05,26.28 U28.22
PWM1F: length 43.2
  TOP w0.152: U62.2 v1(57.78,44.45)
  ART03 w0.152: J2.11 24.38,54.23 28.83,54.23 29.4,53.66 29.4,52.13 30.1,51.44 30.91,51.44 31.62,50.72 31.62,48.9 34.67,45.85 56.39,45.85 v1(57.78,44.45)
PWM1FF: length 32.8
  TOP w0.152: U62.1 v1(60.96,45.72)
  BOTTOM w0.152: U28.23 51.31,25.79 51.56,26.04 52.32,26.04 52.91,26.62 52.91,29.57 53.19,29.84 53.19,31.32 54.69,32.82 56.86,32.82 57.09,32.82 57.55,33.27 57.56,33.27 59.41,35.13 59.41,37.57 60.58,38.73 61.21,38.73 61.53,39.05 61.53,39.94 62.61,41.02 63.5,41.02 64.01,41.53 64.01,44.32 62.61,45.72 v1(60.96,45.72)
RLYCTRL1: length 51
  TOP w0.152: v1(63.52,30.52) 63.52,30.51 63.5,30.51 63.5,30.48 U58.10
  ART03 w0.152: v1(62.87,39.37) 63.75,40.26 63.75,44.7 60.83,47.62 38.11,47.62 J2.2
  BOTTOM w0.152: v1(62.87,39.37) 62.87,39.12 61.53,37.78 60.77,37.78 60.07,37.08 60.07,31.53 60.36,31.24 62.8,31.24 v1(63.52,30.52)
RLYCTRL2: length 52.4
  TOP w0.152: v1(63.5,29.21) 63.5,28.22 63.78,27.94 U58.8
  ART03 w0.152: J2.4 36.84,46.35 57.03,46.35 v1(62.87,40.51)
  BOTTOM w0.152: v1(63.5,29.21) 62.87,29.84 62.87,30.48 62.48,30.86 60.2,30.86 59.69,31.37 59.69,37.24 60.61,38.16 61.28,38.16 61.98,38.86 61.98,39.61 v1(62.87,40.51)
RLYCTRL11: length 47.2
  TOP w0.152: v1(27.3,40.64) 27.3,41.15 27.43,41.27 R703.2 ; U58.11 63.5,31.75 62.23,30.48 v1(62.23,30.23)
  ART03 w0.127: v1(57.63,31.62) 57,32.26 45.95,32.26 40.36,37.85 29.46,37.85 27.3,40.01 v1(27.3,40.64)
  BOTTOM w0.152: v1(62.23,30.23) 61.98,30.48 59.31,30.48 58.59,31.2 58.05,31.2 v1(57.63,31.62) ; U28.133 26.71,40.05 v1(27.3,40.64)
RLYCTRL22: length 46.4
  TOP w0.152: U58.9 64.39,29.21 63.88,29.72 62.61,29.72 v1(62.23,29.34) ; R704.2 27.05,36.45 v1(27.46,36.86)
  ART03 w0.127: v1(57.63,30.66) 56.79,31.5 49.99,31.5 49.73,31.24 46.38,31.24 40.28,37.34 27.94,37.34 v1(27.46,36.86)
  BOTTOM w0.152: v1(27.46,36.86) 27.39,36.79 U28.132 ; v1(62.23,29.34) 60.83,29.34 60.26,29.91 59.25,29.91 58.66,30.49 57.8,30.49 v1(57.63,30.66)
SR-PWM-A: length 37.9
  TOP w0.152: U59.12 63.25,22.23 62.45,21.43 v1(62.1,21.43)
  ART03 w0.127: J3.9 67.69,49.79 67.69,42.8 70.38,40.11 70.38,38.63 62.87,31.11 62.87,28.19 61.72,27.05 61.72,23.88 62.1,23.5 62.48,23.5 62.74,23.24 62.74,22.06 v1(62.1,21.43)
SR-PWM-AA: length 20.7
  TOP w0.152: 65.12,23.5 64.08,23.5 63.4,24.18 v1(63.4,25.3) ; v1(51.94,28.7) 52.45,29.21 R422.2
  ART03 w0.508: v1(59.69,26.04) 57.78,27.94 53.85,27.94 53.09,28.7 v1(51.94,28.7)
  BOTTOM w0.152: v1(51.94,28.7) 51.53,28.28 U28.18 ; v1(63.4,25.3) 62.67,26.04 v1(59.69,26.04)
SR-PWM-B: length 35.9
  TOP w0.152: v1(62.23,25.4) 62.23,24.99 60.73,23.5 59.59,23.5
  ART03 w0.127: v1(62.23,25.4) 62.23,26.8 64.77,29.34 64.77,32.38 70.74,38.36 70.74,40.51 68.45,42.8 68.45,51.57 J3.10
SR-PWM-BB: length 26.4
  TOP w0.152: R423.2 53.47,37.85 v1(53.34,37.85) ; v1(61.07,25.4) 61.07,25.13 60.71,24.77 U59.1
  ART03 w0.127: v1(53.34,37.85) 52.68,37.19 52.68,36.6 52.95,36.33 54.57,36.33 56.36,34.54 57.97,34.54 60.1,32.42 60.1,29.86 61.47,28.49 61.47,27.43 61.07,27.04 v1(61.07,25.4)
  BOTTOM w0.152: v1(53.34,37.85) 52.73,38.46 51.79,38.46 50.95,37.62 50.95,37.06 50.68,36.79 U28.1
SR-PWM-C: length 35.9
  TOP w0.152: U59.4 60.71,20.95 62.07,22.32 62.7,22.32 v1(63.25,22.86)
  ART03 w0.127: v1(63.25,22.86) 63.25,23.88 62.87,24.26 62.87,26.67 65.28,29.08 65.28,32.38 71.12,38.23 71.12,48.9 J3.11
SR-PWM-CC: length 26.8
  TOP w0.152: v1(52.07,36.83) R424.2 ; U59.3 60.83,22.23 61.47,22.86 v1(62.23,22.86)
  ART03 w0.127: v1(62.23,22.86) 60.58,24.51 60.58,27.28 59.44,28.42 59.44,32.52 57.81,34.15 55.94,34.15 54.01,36.08 52.82,36.08 v1(52.07,36.83)
  BOTTOM w0.152: U28.4 50.91,35.28 51.44,35.81 51.44,36.2 v1(52.07,36.83)
SR-PWM-D: length 41.6
  TOP w0.152: v1(63.5,21.59) 63.5,20.7 61.21,18.41 U59.6
  ART03 w0.127: v1(63.5,21.59) 63.87,21.96 63.87,21.98 64.35,22.46 64.35,25.06 63.5,25.91 63.5,26.54 65.79,28.83 65.79,32.38 71.5,38.1 71.5,51.06 J3.12
SR-PWM-DD: length 28.3
  TOP w0.152: v1(62.1,20.19) 61.59,19.68 U59.5 ; R425.2 54.46,35.59 v1(53.19,35.59)
  ART03 w0.127: v1(62.1,20.19) 60.2,22.1 60.2,26.95 58.93,28.22 58.93,32.51 57.66,33.78 55.45,33.78 53.64,35.59 v1(53.19,35.59)
  BOTTOM w0.152: U28.6 51,34.28 51.69,34.98 52.36,34.98 52.77,35.38 52.77,35.38 52.97,35.59 v1(53.19,35.59)
TCK_P: length 8.6
  TOP w0.152: v1(29.86,11.54) 30.64,10.77 32.64,10.77 33.05,10.36 33.05,9.63 33.66,9.02 R408.2 R407.2
  BOTTOM w0.152: U28.81 30.22,11.82 29.94,11.54 v1(29.86,11.54)
TDI_P: length 18.2
  TOP w0.152: R405.2 v1(29.84,6.35) 29.2,5.7 28.44,5.7 27.92,5.18 27.92,3.2 J5.3
  BOTTOM w0.152: v1(29.84,6.35) 30.38,5.82 32.23,5.82 32.71,6.29 32.71,9.43 33.03,9.74 33.03,10.37 32.22,11.18 U28.77
TDO_P: length 13.9
  TOP w0.152: J5.7 33.01,3.19 33.01,5.09 v1(31.75,6.35) 32.38,6.99 R406.2
  BOTTOM w0.152: v1(31.75,6.35) 31.71,6.39 U28.78
TMS_P: length 15.7
  TOP w0.152: R404.2 v1(26.04,6.35) 25.18,5.5 25.18,3.39 J5.1
  BOTTOM w0.152: v1(26.04,6.35) 29.24,9.56 29.24,10.44 29.67,10.87 30.07,10.87 30.71,11.51 U28.80
VO1+: length 16.3
  BOTTOM w0.508: J4.1 90.05,41.41 R574.1
VO2+: length 11.9
  TOP w0.508: J4.3 84.71,49.28 84.71,44.83 88.27,41.27 R573.1
VP3.3A: length 55.6
  TOP w0.381: C521.1 v1(48.26,19.05)
  TOP w0.508: v1(41.91,6.73) 42.7,6.73 42.86,6.89 D127.2 ; C550.2 v1(43.81,15.24) ; v1(54.29,6.05) D89.2 ; v1(57.4,27.05) 57.96,27.61 57.96,29.41 v1(57.61,29.77)
  ART03 w0.381: v1(34.19,6.25) 35.05,7.11 41.53,7.11 v1(41.91,6.73) 42.93,5.71 46.86,5.71 47.88,6.73 50.8,6.73 v1(51.44,6.1)
  ART03 w0.508: v1(57.4,27.05) 56.77,26.42 56.77,24.7 v1(57.66,23.82)
  BOTTOM w0.254: U28.36 48.49,19.28 v1(48.26,19.05) ; v1(43.81,15.24) 43.71,15.14 U28.54
  BOTTOM w0.381: v1(34.19,6.25) 33.89,6.25 33.34,6.79 D86.2 ; 56.44,4.83 55.51,4.83 v1(54.29,6.05) 54.51,6.05 55.07,6.6 55.07,8.05 54.74,8.38 54.07,8.38 53.82,8.13 52.83,8.13 52.39,7.69 D115.2
  BOTTOM w0.508: v1(51.44,6.1) 51.64,6.1 52.39,6.85 D115.2 ; v1(57.4,27.05) 57.34,26.99 D85.2 ; v1(57.61,29.77) 57.15,29.77 56.75,30.17 D84.2 ; D92.2 v1(57.66,23.82) 57.28,23.43 57.28,21.31 v1(57.53,21.06) ; v1(41.91,6.73) 41.83,6.65 41.15,6.65 40.96,6.84 D90.2
  vias: v1(60.83,10.79) v1(61.85,10.79)
VP3.3D: length 163.3
  TOP w0.381: R411.1 R412.1 47.11,2.03 48.39,0.76 63.88,0.76 ; D125.2 v1(23.17,39.5) ; D126.2 v1(20,39.5) ; v1(26.67,16.51) 26.67,16.63 C540.1 ; D95.2 v1(16.82,39.5) 16.76,39.5 16.59,39.33 15.58,39.33 15.4,39.5 14.48,39.5 13.97,38.99 13.97,37.08 13.21,36.32 ; R691.1 v1(15.88,45.09) ; C541.2 v1(27.94,15.24) ; D124.2 26.35,38.8 26.16,38.99 25.59,38.99 v1(25.4,38.8)
  TOP w0.508: C542.2 v1(29.84,15.24) ; C533.1 26.16,32.38 v1(26.67,32.89) ; R405.1 v1(29.84,10.16) ; J17.2 77.91,8.41 R598.1 ; C524.2 v1(40.01,36.83) ; C523.2 44.32,36.96 v1(44.2,36.83) ; v1(5.43,21.66) 5.59,21.82 R540.1 ; R406.1 v1(32.38,10.16) ; C546.2 v1(36.83,15.24) ; v1(36.2,10.16) 35.94,9.91 35.94,8 35.43,7.5 R407.1 ; R687.1 v1(20.32,45.09) ; R409.2 v1(31.11,10.16) ; v1(48.26,24.13) C557.2 C552.1 ; v1(21.97,26.54) 21.97,27.3 21.34,27.94 R546.2 20.57,27.3 v1(20.57,26.54) ; v1(29.59,36.83) 29.84,37.08 C529.2 ; C537.1 v1(26.67,27.3) ; R327.2 31.11,40.64 ; C536.1 v1(26.67,28.57) ; C539.1 v1(26.67,20.32) ; C545.2 v1(34.92,15.24) ; R685.1 v1(22.23,45.09) ; J18.2 20.95,8.29 v1(20.95,9.84) C406.2 ; C534.1 v1(26.67,31.11) ; D104.2 49.46,43.25 v1(49.53,43.18) ; 13.21,36.32 11.3,34.41 R537.2 ; v1(34.92,36.83) C527.2 ; R688.1 v1(25.4,45.09) ; C555.2 v1(48.26,27.94) ; C531.1 v1(26.67,34.92) ; v1(39.37,15.24) 38.61,15.24 38.23,14.86 C547.2 ; R404.1 v1(26.04,10.16) ; C553.2 49.28,33.02 48.26,32 v1(48.26,31.75) ; C528.2 v1(33.66,36.83) ; R400.2 37.47,40.64 ; C544.2 v1(33.66,15.24) ; C538.1 v1(26.67,23.5) ; C520.1 50.92,40.51
  BOTTOM w0.254: 48.26,29.79 U28.15 ; v1(44.2,36.83) 44.22,36.85 U28.168 ; U28.152 36.22,37.82 35.23,36.83 v1(34.92,36.83) ; U28.88 26.71,15.2 v1(26.67,15.24) ; v1(26.67,20.32) 26.63,20.28 U28.99 ; U28.91 26.44,16.28 v1(26.67,16.51) ; U28.119 26.22,30.28 26.67,30.73 v1(26.67,31.11) 26.04,31.11 25.71,30.79 U28.120 ; U28.147 33.71,36.89 v1(33.66,36.83) ; U28.20 48.92,27.28 v1(48.26,27.94) ; U28.159 39.71,37.12 v1(40.01,36.83) ; U28.72 34.71,15.03 v1(34.92,15.24) ; v1(33.66,15.24) 33.22,14.8 U28.75 ; v1(39.37,15.24) 39.71,14.9 U28.62 ; U28.82 29.71,15.11 v1(29.84,15.24) ; U28.127 26.03,34.28 v1(26.67,34.92) ; v1(26.67,28.57) 26.46,28.79 U28.116 ; U28.125 26.28,33.28 v1(26.67,32.89) ; U28.3 48.49,35.79 ; v1(29.59,36.83) 29.22,37.21 U28.138 ; v1(26.67,23.5) 26.38,23.79 U28.106 ; v1(48.26,31.75) 48.3,31.79 U28.11 ; v1(26.67,27.3) 26.19,27.79 U28.114 ; U28.26 48.41,24.28 v1(48.26,24.13) ; U28.68 36.71,15.12 v1(36.83,15.24)
  BOTTOM w0.508: R437.2 R438.2 v1(66.67,38.1) ; 67.94,33.18 67.94,31.62 68.96,30.6 C396.1 70.36,30.6 v1(71.12,29.84) ; J17.2 78.11,8.22 C405.1 ; v1(67.94,38.1) 67.94,37.59 R439.2 ; v1(70.99,35.31) 71,35.31 71.5,34.8 R502.1 ; R505.1 v1(71.12,32.38)
  vias: v1(3.81,46.35) v1(3.81,45.09) v1(5.08,46.35) v1(5.08,45.09) v1(6.35,46.35) v1(6.35,45.09) v1(6.35,11.43) v1(6.35,10.16) v1(6.35,8.89) v1(7.62,11.43) v1(7.62,10.16) v1(7.62,8.89) v1(27.94,16.51) v1(29.84,16.51) v1(49.53,41.91) v1(51.44,41.91) v1(52.7,41.91) v1(53.98,41.91) v1(66.04,5.08) v1(67.31,5.08) v1(68.58,5.08) v1(69.85,5.08) v1(71.75,1.27) v1(73.03,1.27) v1(74.3,1.27)
VP+5V: length 37.3
  TOP w0.381: C494.1 53.77,27.94 53.34,27.51 53.34,26.67 53.66,26.35 U55.1 58.55,26.35 58.99,26.8 60.33,26.8 60.58,27.05 68.58,27.05 v1(69.22,26.42) ; R549.2 v1(70.48,33.02)
  TOP w0.508: R536.2 9.01,30.86 v1(9.02,30.86) ; v1(69.22,26.42) 69.34,26.29 R550.2 ; R612.2 v1(70.48,45.72)
  BOTTOM w0.381: v1(70.48,45.72) 70.48,45.59 71.63,44.45 71.63,40.13 v1(74.3,37.47)
  BOTTOM w0.508: R594.2 71.38,26.04 70.87,25.52 R595.2 69.85,25.78 v1(69.22,26.42)
  vias: v1(6.1,32.77) v1(6.1,31.62) v1(6.1,30.48) v1(7.74,30.86) v1(10.29,30.86) v1(11.3,30.86) v1(52.7,5.08) v1(53.98,5.08) v1(53.98,3.81)
VS+5V: length 28.8
  TOP w0.508: R496.1 v1(92.59,34.42) ; v1(98.3,23.75) 97.91,24.13 R492.2 ; R507.1 v1(97.91,32.26) ; v1(95.89,23.75) 95.89,23.6 95.4,23.12 R493.1
  TOP w0.762: J4.7 88.9,43.56 91.56,40.9 v1(91.56,38.1)
  ART03 w0.508: v1(88.9,35.56) 92.2,35.56
  BOTTOM w0.508: R569.1 v1(88.9,35.56) ; R593.2 91.87,26.04 v1(92.53,26.7) ; R597.1 v1(91.56,38.1) R500.1 ; R503.1 91.69,32.89 92.2,32.89 v1(92.71,32.38) ; R592.2 v1(88.9,20.95)
X1: length 9.1
  BOTTOM w0.254: Y1.1 17.62,33.08 20.13,33.08 C371.2 21.2,32.9 R221.1 21.82,32.28 U28.123
X2: length 9.3
  BOTTOM w0.254: Y1.2 18.44,31.24 C254.2 21.34,31.24 R221.2 21.64,30.99 21.94,31.28 U28.121
XRS: length 28
  TOP w0.508: R547.1 10.92,28 11.18,27.74 11.18,25.32 10.29,24.43 10.29,23.5 R541.1 15.89,23.5 19.82,27.43 19.82,30.46 20.1,30.74 R546.1 21.71,31.24 C519.1 21.71,33.78 v1(21.72,33.78)
  BOTTOM w0.254: U28.124 23.73,32.79 23.37,33.15 22.35,33.15 v1(21.72,33.78)
N16777869: length 9.4
  TOP w0.152: R408.1 35.54,5.61 35.54,3.19 J5.9 J5.11
N16778586: length 5.7
  TOP w0.152: v1(46.35,11.43) R701.2 C702.1 R700.2
  BOTTOM w0.152: v1(46.35,11.43) 46.22,11.57 U28.49
N16779815: length 3.6
  TOP w0.152: v1(30.66,36.83) 31.11,37.29 R327.1
  BOTTOM w0.152: U28.139 29.71,37.77 v1(30.66,36.83)
N16779840: length 4
  BOTTOM w0.152: DAC_6.1 30.61,40.77 30.61,40.26 30.22,39.87 U28.140
N16809513: length 6.4
  TOP w0.152: J5.5 30.5,3.15 30.5,6.3 31.11,6.91 R409.1
N16810933: length 3.9
  TOP w0.152: J5.13 42.55,2.54 R412.2
N16810951: length 3.9
  TOP w0.152: R411.2 42.55,3.81 J5.14
N16833081: length 2.1
  TOP w0.152: D102.1 R443.1
N16833084: length 2.3
  TOP w0.152: R444.1 43.81,46.87 D103.1
N16833087: length 2.6
  TOP w0.152: D104.1 45.72,46.23 R445.1
N16835391: length 31.4
  TOP w0.152: J17.1 69.85,8.26 v1(66.04,12.06)
  ART03 w0.127: v1(66.04,12.06) 66.04,13.59 59.28,20.35 v1(58.09,20.35)
  BOTTOM w0.152: R446.1 C407.1 J17.1 ; R447.1 56.59,21.21 57.45,20.35 v1(58.09,20.35)
N16836592: length 56.2
  TOP w0.152: J18.1 18.41,9.53 19.05,10.16 R448.1 ; R448.1 19.56,11.31 19.94,11.68 19.94,14.47 21.25,15.78 26.91,15.78 27.26,16.12 27.26,17.09 27.26,17.1 v1(27.94,17.78) ; R448.1 C409.1
  ART03 w0.127: v1(58.01,21.79) 58,21.78 54.42,21.78 52.2,19.56 45.36,19.56 44.32,18.52 28.68,18.52 v1(27.94,17.78)
  BOTTOM w0.152: v1(58.01,21.79) 58.67,22.45 58.67,25.02 59.05,25.4 59.05,26.54 R449.1
N16848574: length 4.1
  BOTTOM w0.508: C446.1 R482.2 89.92,24.64 88.14,24.64 88.01,24.77 U43.2
N16848598: length 4.6
  BOTTOM w0.381: R593.1 C445.2
  BOTTOM w0.508: U43.1 88.14,26.04 89.41,27.3 C445.2
N16848614: length 4.8
  TOP w0.508: C447.2 75.44,24.89 v1(74.93,25.4)
  BOTTOM w0.152: R594.1 74.3,26.04 v1(74.93,25.4) 75.13,25.4 75.77,26.04 U43.8
N16848642: length 2.8
  BOTTOM w0.152: R483.1 U43.7
N16848644: length 12.7
  TOP w0.152: v1(66.8,16.89) 66.93,16.89 v1(71.12,21.08)
  BOTTOM w0.152: v1(71.12,21.08) 72.26,22.23 C448.2 R484.2 R483.2 ; U45.3 65.41,17.4 65.91,16.89 v1(66.8,16.89)
N16848814: length 4.5
  BOTTOM w0.152: 76.54,23.5 75.18,23.5 74.68,22.99 74.68,21.85 R485.1
N16848816: length 7.8
  BOTTOM w0.152: U45.2 66.67,18.92 67.31,19.56 68.83,19.56 69.22,19.17 C449.1 R486.1 71.12,19.81 72.26,20.95 R485.2
N16848832: length 25.6
  TOP w0.152: R487.1 55.88,10.31 v1(55.27,10.92)
  ART03 w0.127: v1(68.83,16.76) 68.83,12.57 67.44,11.18 63.88,11.18 62.87,10.16 60.17,10.16 58.85,11.48 55.83,11.48 v1(55.27,10.92)
  BOTTOM w0.152: R486.2 C449.2 69.85,17.65 68.96,16.76 v1(68.83,16.76) 67.94,17.65 67.94,18.25
N16848970: length 3.4
  BOTTOM w0.152: U44.6 96.52,20.5 96.22,20.19 95.5,20.19 95.25,20.45 U44.7
N16848978: length 9.7
  TOP w0.152: v1(96.9,23.75) 96.4,24.25 R492.1 R489.2 C453.2 R488.2 C454.1
  BOTTOM w0.152: U44.3 96.52,24.03 96.8,23.75 v1(96.9,23.75)
N16848994: length 10.6
  TOP w0.152: R494.2 R493.2 ; R494.2 93.07,24.64 v1(92.71,24.99) 91.97,24.25 R491.1 C455.1 ; R494.2 93.47,24.76 C454.2
  BOTTOM w0.152: v1(92.71,24.99) 94.59,24.99 95.25,25.66 U44.2
N16849016: length 4.4
  BOTTOM w0.152: U44.8 93.98,22.07 93.83,22.23 C457.1 R592.1
N16851028: length 3.3
  BOTTOM w0.152: U45.7 66.67,24.61 66.52,24.77 65.56,24.77 65.41,24.61 U45.6
N16851046: length 4.3
  BOTTOM w0.152: 67.94,23.66 67.94,24.13 68.2,24.38 68.83,24.38 69.21,24.01 R595.1 C451.1
N16853569: length 5.3
  TOP w0.152: v1(95.89,34.29) 95.76,34.41 R495.2 C458.1 C460.1
  BOTTOM w0.152: U48.3 v1(95.89,34.29)
N16853931: length 10.1
  TOP w0.152: C460.2 97.28,38.61 96.82,39.07 94.51,39.07 94.1,38.66 R497.1 C459.1 R496.2 94.1,34.8 v1(94.61,34.29)
  BOTTOM w0.152: U48.2 v1(94.61,34.29)
N16853972: length 7.6
  BOTTOM w0.152: U48.1 93.18,35.56 R569.2 91.56,35.05 90.81,34.29 89.03,34.29 88.39,33.66 86.94,33.66
N16854025: length 17.4
  ART03 w0.508: v1(90.17,38.1) 89.03,38.1 87.76,36.83 87.76,30.86 v1(88.9,29.72)
  BOTTOM w0.508: v1(88.9,29.72) 89.28,30.1 C462.1 C566.1 91.44,30.1 92.08,29.46 93.09,29.46 93.34,29.72 U48.8 ; R597.2 90.05,38.22 v1(90.17,38.1)
N16854569: length 3.4
  BOTTOM w0.152: R500.2 89.03,36.83 88.39,36.2 U60.1
N16855013: length 10.3
  TOP w0.152: C466.2 93.47,32.01 94.23,32.77 95.89,32.77 v1(96.39,32.26) 96.4,32.26 R507.2 C467.1 R508.1
  BOTTOM w0.152: U48.5 97.16,31.5 v1(96.39,32.26)
N16855828: length 6
  TOP w0.152: R506.2 C465.1 C466.1 94.99,31.87 v1(95.38,32.26)
  BOTTOM w0.152: v1(95.38,32.26) 95.89,31.75 U48.6
N16855912: length 9.3
  BOTTOM w0.152: U48.7 94.61,29.34 93.85,28.57 90.05,28.57 89.61,28.14 88.29,28.14 87.86,28.57 U61.2
N16855916: length 3.9
  BOTTOM w0.152: R503.2 88.14,31.11 U61.1
N16860426: length 83
  TOP w0.152: C472.1 75.63,13.34 v1(75.25,12.95) ; C472.1 R598.2 ; C472.1 C471.1
  ART03 w0.127: v1(75.25,12.95) 73.11,10.82 64.26,10.82 63.22,9.78 59.92,9.78 58.55,11.15 56.49,11.15 55.63,10.29 54.99,10.29 54.04,11.24 54.04,11.75 52.83,12.95 38.61,12.95 37.59,11.94 37.59,10.79 36.32,9.53 25.91,9.53 21.97,13.46 21.97,13.97 18.41,17.53 v1(18.41,24.13)
  BOTTOM w0.152: v1(75.25,12.95) 75.25,11.62 75.44,11.43 U53.1 ; R515.1 R514.1 v1(18.41,24.13)
N16860580: length 10.1
  TOP w0.508: C473.1 C475.1 C474.1 R516.2 90.32,12.04 90.83,12.04 91.31,11.56 v1(91.44,11.56)
  BOTTOM w0.508: v1(91.44,11.56) 91.31,11.43 U53.8
N16860640: length 9.2
  TOP w0.152: v1(84.45,13.97) D110.2 D112.1
  BOTTOM w0.152: T1.2 U53.7 v1(84.45,13.97)
N16861242: length 8.5
  BOTTOM w0.152: J11.2 94.74,8.73 R517.1 94.74,11.47 97.24,13.97 T1.3
N16861249: length 9.3
  TOP w0.152: v1(84.45,16.51) D114.1 D113.2
  BOTTOM w0.152: v1(84.45,16.51) U53.6 T1.1
N16861268: length 11.3
  BOTTOM w0.152: J11.1 93.22,8.77 R517.2 93.22,11.89 97.84,16.51 T1.4
N16861373: length 4.3
  TOP w0.381: D114.2 D112.2 89.66,15.24 90.3,14.61 90.77,14.61 D111.2
N16900365: length 4.1
  TOP w0.508: Q1.1 7.93,33.72 8.76,32.9 R538.2 R537.1
N16900541: length 7.3
  TOP w0.508: v1(8.4,27.46) 8.4,27.92 C505.1 7.5,28.82 R536.1 6.99,30.36 Q1.3
  BOTTOM w0.381: U57.7 8.58,27.64 v1(8.4,27.46)
N16908509: length 4.6
  TOP w0.508: R541.2 R540.2 7.11,24.2 7.41,24.51 v1(7.75,24.51)
  BOTTOM w0.381: U57.19 7.93,24.33 v1(7.75,24.51)
N16935004: length 2.7
  TOP w0.508: R547.2 9.4,27.48 v1(9.41,27.47)
  BOTTOM w0.381: v1(9.41,27.47) 9.23,27.65 U57.8
N17022031: length 6.6
  TOP w0.152: U58.14 C560.1 C562.1 R549.1 C561.1
N17025421: length 6.5
  TOP w0.152: U59.14 R550.1 C563.1 C565.1 C564.1
N17096901: length 14.1
  TOP w0.381: R488.1 93.46,27.32 91.55,27.32 C237.2 R133.1 90.14,27.4 90.14,35.46 R573.2
N17102058: length 20.4
  TOP w0.152: R506.1 92.86,28.57 91.85,29.59 91.85,32.44 92.86,33.45 96.06,33.45 96.52,33.91 96.52,34.08 96.52,34.08 96.52,34.67 96.93,35.08 96.93,35.21 R495.1 v1(98.42,35.56)
  BOTTOM w0.152: R574.2 93.99,38.61 C594.1 R575.1 97.69,38.61 97.92,38.38 97.92,36.07 v1(98.42,35.56)
N17145229: length 8.6
  BOTTOM w0.152: R599.2 C595.1 43.82,8.38 42.7,8.38 42.55,8.53 42.55,10.29 42.04,10.79 42.04,11.94 42.22,12.12 U28.57
N17182974: length 87.5
  TOP w0.152: R528.1 C488.1 R58.2 R529.1 50.42,11.68 v1(50.16,11.43)
  ART03 w0.127: v1(50.16,11.43) 49.53,10.79 39.27,10.79 38.53,10.06 38.53,9.78 37.19,8.43 25.22,8.43 22,11.66 18.31,11.66 13.34,16.63 13.34,45.71 10.54,48.51 7.37,48.51 5.71,50.16 v1(5.71,50.17)
  BOTTOM w0.152: R49.1 4.95,49.41 v1(5.71,50.17)
N17183073: length 4.3
  TOP w0.152: R533.1 C492.1 54.49,20.44 53.98,20.95 R532.2 R534.1
N17183105: length 2.3
  TOP w0.152: U55.2 53.66,24.45 53.47,24.26 53.47,23.49 R532.1
N17207390: length 6.6
  TOP w0.152: U62.14 R612.1 C602.1 C600.1 C601.1
N17215412: length 10.3
  BOTTOM w0.152: R679.1 57.66,14.22 57.41,13.97 56.13,13.97 55.18,14.92 53.91,14.92 52.45,16.38 51.31,16.38 51.21,16.28 U28.42
N17215422: length 3.9
  BOTTOM w0.152: R678.1 52.07,15.88 51.94,16 51.31,16 51.09,15.79 U28.43
N17215466: length 5.2
  BOTTOM w0.152: R681.2 61.47,14.09 DAC_5.1 ; R681.2 59.69,14.86 59.18,15.37 R679.2 ; R681.2 C691.2
N17215490: length 4.5
  BOTTOM w0.152: DAC_4.1 56.39,12.58 R680.2 C690.2 R678.2
N17215663: length 8.4
  BOTTOM w0.152: U28.47 47.22,12.6 48.26,11.56 48.26,10.79 47.62,10.16 DAC_1.1 47.75,9.01 C687.2 R673.2
N17215880: length 6.3
  TOP w0.152: v1(51.56,15.49) 52.96,16.89 R607.2 C598.1
  BOTTOM w0.152: v1(51.56,15.49) 51.35,15.28 U28.44
N17228521: length 68.3
  TOP w0.152: R693.1 38.56,7.5 38.81,7.75 38.81,9.6 39.2,9.99 39.61,9.99 v1(39.62,10.01)
  ART03 w0.127: v1(8.76,37.47) 11.18,37.47 12.57,36.07 12.57,15.02 16.8,10.79 21.34,10.79 24.52,7.62 38.1,7.62 39.62,9.14 v1(39.62,10.01)
  BOTTOM w0.152: R692.1 C698.1 R695.2 12.69,37.97 R694.1 9.66,37.47 v1(8.76,37.47)
N17238858: length 14.4
  BOTTOM w0.152: U28.38 51.05,18.28 51.44,18.67 51.44,19.56 52.32,20.45 56.95,20.45 57.58,19.81 58.3,19.81 58.6,20.12 59.26,20.12 59.57,20.42 R696.2 C700.1 R697.2
N17241205: length 12.4
  BOTTOM w0.152: U28.40 51.42,17.28 51.56,17.14 53.34,17.14 53.85,17.65 57.41,17.65 C701.1 R699.2 R698.2
N16779431153: length 3.1
  TOP w0.152: R400.1 v1(37.47,36.83)
  BOTTOM w0.152: v1(37.47,36.83) 37.22,37.08 U28.154

## Copper pours and planes (outline as drawn)
AGND on TOP (solid shape): 43.45,29.63 43.45,24.1 41.65,22.3 38.9,22.3 37.89,21.29 33.32,21.29 31.64,22.97 31.64,31.9 32.32,32.58 40.5,32.58
AGND on TOP (solid shape): 14.89,15.06 14.89,10.29 15.4,9.78 15.4,3.67 15.37,3.64 15.37,1.09 14.85,0.57 0.93,0.57 0.59,0.91 0.59,11.42 0.95,11.78 3.91,11.78 4.24,11.45 4.24,8.37 3.8,7.93 2.32,7.93 1.47,7.08 1.47,2.91 2.42,1.97 10.44,1.97 11.73,3.25 11.73,15.06 12.1,15.43 14.52,15.43
AGND on TOP (solid shape): outline of 184 points within 11.83,24.07 23.18,37.21
AGND on BOTTOM (solid shape): 43.19,31.06 43.19,21.89 42.1,20.8 32.22,20.8 31.23,21.79 31.23,31.28 31.85,31.9 42.35,31.9
AGND on BOTTOM (solid shape): 53.94,2.79 53.94,0.69 53.81,0.56 45.01,0.56 44.86,0.71 44.86,1.77 45.02,1.93 48.44,1.93 48.86,1.51 52.06,1.51 52.39,1.84 52.39,2.83 52.53,2.97 53.76,2.97
AGND on BOTTOM (solid shape): 61.82,2.52 65.34,2.52 65.68,2.86 70.05,2.86 70.24,2.66 70.24,1.12 69.94,0.82 56.94,0.82 56.65,1.11 56.65,2.28 56.87,2.5 58.86,2.5 59.22,2.86 61.48,2.86
AGND on BOTTOM (solid shape): 82.1,19.81 82.1,0.85 81.82,0.57 75.45,0.57 75.26,0.76 75.26,1.38 75.55,1.66 78.71,1.66 79.62,2.57 79.62,10.76 78.92,11.46 78.92,19.73 79.18,19.99 81.92,19.99
AGND on BOTTOM (solid shape): outline of 204 points within 0.56,3.81 23.39,38.4
AGND on ART02 (solid shape): outline of 16591 points within 0.56,0.56 81.28,54.44
AGND on ART03 (solid shape): 44.15,29.09 44.15,20.5 43.63,19.98 30.48,19.98 29.8,20.66 29.8,30.38 30.36,30.94 42.29,30.94
AGND on ART03 (solid shape): outline of 195 points within 14.5,13.3 21.4,37.59
SGND on TOP (solid shape): outline of 887 points within 82.42,19.97 99.44,54.44
SGND on BOTTOM (solid shape): outline of 889 points within 82.53,22.39 99.44,54.44
SGND on ART02 (solid shape): outline of 1781 points within 82.93,19.94 99.44,54.44
VDD on TOP (solid shape): outline of 287 points within 7.66,3.28 48.64,37.21
VDD on BOTTOM (solid shape): 10.12,23.98 10.29,23.95 10.46,23.98 11.21,23.98 11.37,23.82 11.37,21.29 10.73,20.65 10.73,6.14 11.07,5.8 11.07,4.09 10.88,3.9 7.96,3.9 7.81,4.05 7.81,5.82 8.89,6.9 8.89,21.15 9.7,21.96 9.7,23.75 9.92,23.98
CAN5V_GND on TOP (solid shape): outline of 119 points within 85.98,0.61 99.44,19.4
CAN5V_GND on BOTTOM (solid shape): 99.44,0.56 89.53,0.56 89.53,1.12 89.49,1.17 89.49,7.37 88.72,8.15 86.32,8.15 85.98,8.48 85.98,10.21 86.32,10.55 90.37,10.55 91.47,9.44 91.47,7.19 91.77,6.9 96.23,6.9 96.53,7.19 96.53,11.86 96.74,12.06 99.44,12.06
CAN5V_GND on ART02 (solid shape): outline of 329 points within 83.4,0.56 99.44,19.43
CAN5V_GND on ART03 (solid shape): outline of 325 points within 83.41,0.59 99.4,19.38
P_ADREF3.2V on TOP (solid shape): outline of 279 points within 40.13,3.56 50.8,20.57
P_ADREF3.2V on BOTTOM (solid shape): 51.75,5.32 51.75,2.16 51.63,2.03 49.24,2.03 48.61,2.66 48.61,5.37 48.73,5.49 51.59,5.49
VP3.3A on BOTTOM (solid shape): 62.98,10.93 62.98,3.23 62.87,3.13 61.93,3.13 61.5,3.55 58.99,3.55 58.67,3.86 56.57,3.86 56.36,4.07 56.36,5.08 56.75,5.46 59.03,5.46 59.04,5.47 59.7,5.47 60.07,5.84 60.07,11.05 60.2,11.18 62.73,11.18
VP3.3A on ART03 (solid shape): outline of 976 points within 43.31,10.48 63.37,21.46
VP3.3D on TOP (solid shape): outline of 720 points within 48.64,0.63 79.5,48.39
VP3.3D on TOP (solid shape): outline of 1552 points within 0.56,8.13 37.86,54.44
VP3.3D on BOTTOM (solid shape): 74.68,5.72 74.68,1.08 74.5,0.9 70.89,0.9 70.74,1.05 70.74,3.02 70.27,3.49 65.6,3.49 65.25,3.14 64.11,3.14 64.03,3.21 64.03,4.32 64.03,5.66 64.03,5.66 64.03,5.92 64.11,6 74.4,6
VP3.3D on BOTTOM (solid shape): outline of 1013 points within 1.02,0.69 54.61,51.31
VP3.3D on ART03 (solid shape): outline of 1241 points within 16.51,9.84 39.91,40.13
VP+5V on BOTTOM (solid shape): 54.57,5.12 54.57,3.68 54.28,3.4 52.5,3.4 52.49,3.41 52.49,5.33 52.59,5.43 54.26,5.43
VP+5V on BOTTOM (solid shape): 12.06,32.94 12.23,32.94 12.38,32.79 12.38,31.72 12.38,31.71 12.38,31.08 11.38,30.08 11.38,28.27 11.21,28.1 10.53,28.1 10.35,28.27 10.35,30.2 9.99,30.56 6.5,30.56 6.16,30.21 6.16,28.21 6.1,28.15 5.24,28.15 5.15,28.24 5.15,30.23 4.83,30.56 2.9,30.56 2.69,30.76 2.69,32.61 3.03,32.95 12.05,32.95
VP+5V on ART03 (solid shape): outline of 6320 points within 0.56,0.56 82.23,54.44
VS+5V on ART03 (solid shape): outline of 886 points within 88.27,20.33 99.42,38.73
N16830570 on BOTTOM (solid shape): 47.92,5.33 47.92,2.88 47.71,2.66 45.17,2.66 44.81,3.03 44.81,5.08 45.19,5.46 47.8,5.46

## Text on the board
BOTTOM: ARTWORK BOTTOM
Board Geometry/Soldermask Bottom: SOLDERMASK BOTTOM
Package Geometry/Pastemask Bottom: PASTEMASK BOTTOM
Ref Des/Silkscreen Bottom: A | SILKSCREEN BOTTOM
TOP: ARTWORK TOP
Board Geometry/Soldermask Top: SOLDERMASK TOP
Package Geometry/Pastemask Top: PASTEMASK TOP
Ref Des/Silkscreen Top: B | A | REB 1220 | CRD22AD12N/CRD22DD12N Control board | SILKSCREEN TOP
ART02: ARTWORK LAYER02
ART03: ARTWORK LAYER03
DIMENSION: Board Cut Out | V-cut | FAB DRAWING
ASSEMBLY_TOP: PRIMARY SIDE
ASSEMBLY_BOTTOM: SECONDARY SIDE
User.7: ARTWORK LAYER03
User.9: ARTWORK LAYER02
User.21: FIGURE | SIZE | 12.0 | 32.0 | 35.0 | 39.0 | 40.0 | 45.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | QTY | 507 | 2 | 6 | 48 | 4 | 14
